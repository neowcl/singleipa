# Keil uVision project CBMX56X.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: CBM6560 Chipsea
  pack: Chipsea.CBMX56X_DFP.1.0.5
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0xF000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CBMX56X_fw +hex
  AfterMake: fromelf.exe --bin --bincombined --bincombined_padding=1,0xff --output @L.bin !L
  AfterMake: CBM8560_bin.exe
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\src\App\inc;..\src\Core\Inc;..\src\Core\src;..\src\Modules;..\src\SOC_CodeGenXHCell;..\src\Modules\modules_reg;..\src\App\src;..\src\Device\Driver;..\src\Device\Include;..\src\Device\Driver\inc;..\src\Algorithm_api
  memory RVCT4: ROM 0x0 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: ..\Output\Objects\CBMX56X_fw.sct
  group Application
    ../src/Core/src/: main.c api_implement.c comm_protocol.c data_flash.c i2c_coms.c isr.c isr.h task.c utility.c utility.h standard_data_cmd.c standard_data_cmd.h block_command.c block_command.h
    ../src/Core/inc/: main_interface.h
    ../src/Modules/: user_config.h
  group IIC_APP
    ../src/App/src/: app_crc.c app_debug_mode_handle.c app_inc.h app_reg_cmd_handle.c app_slave_io_event_handle.c app_task.c bms_register_inc.h
  group Modules
    ../src/Modules/: modules_current.c modules_fmc.c modules_init.c modules_pmu.c modules_temp.c modules_vbat.c
  group singgle
    ../src/Core/src/: bi2cs_interface.h bi2cs_interface.c Cell.c Cell.h Ram.c Ram.h datcalc_spl.c datcalc_spl.h LifeTime.c LifeTime.h Calc_CVT.c Calc_CVT.h Mode.c Mode.h Protect.c Protect.h
    ../src/Core/inc/: base_types.h
  group MyI2C
    ../src/MyI2C/: MyI2C.lib
software components: CMSIS:CORE 5.5.0, Device:HAL:Framework 1.0.5, Device:Startup 1.0.5
